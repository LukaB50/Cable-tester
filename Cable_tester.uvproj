# Keil uVision project Cable_tester.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Cable_tester
  c flags: Optim=1
  c include: .\inc;..\PACK_LPX1700\Keil\LPC1700_DFP\2.4.0\Device\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ./: startup_LPC17xx.s
    ../PACK_LPC1700/Keil/LPC1700_DFP/2.4.0/Device/Source/: system_LPC17xx.c
  group src
    ./src/: config_pin.c startup_LPC17xx.s timers.c main.c
    ./: pomocni.c
  group inc
    ./inc/: config_pin.h main.h timers.h

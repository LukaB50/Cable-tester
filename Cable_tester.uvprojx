# Keil uVision project Cable_tester.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Cable_tester
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\inc;..\PACK_LPX1700\Keil\LPC1700_DFP\2.4.0\Device\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ./src/: startup_LPC17xx.s
    ./: system_LPC17xx.c
  group src
    ./src/: config_pin.c startup_LPC17xx.s timers.c main.c gpio.c pomocni.c uart.c logic.c
  group inc
    ./inc/: config_pin.h main.h timers.h gpio.h uart.h logic.h
software components: CMSIS:CORE 5.1.2
